# Keil uVision project FreeRTOS.uvprojx, settings and files
target STM32_OSC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_M,DEBUG_INFO=02
  c include: ..\FWLIB\inc;..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\DSP_LIB\Include;..\DSP_LIB;..\STemWin_Task
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c stm32f4xx.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_adc.c
    ./: system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/LED/: bsp_led.c
    ../HARDWARE/DAC/: bsp_dac.c
    ../HARDWARE/ADC/: bsp_adc.c
    ../HARDWARE/TimBase/: bsp_TiMbase.c
    ../HARDWARE/LOG/: bsp_log.h
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group STemWin_Task
    ../STemWin_Task/: dso.c
  group README
    ../: readme.txt
